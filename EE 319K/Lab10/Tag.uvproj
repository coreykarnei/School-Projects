# Keil uVision project Tag.uvproj, settings and files
target Tag (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Tag
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s random.s TExaS.c DAC.c ADC.c Timer0.c Timer1.c Sound.c Print.s ST7735.c LCD.s Player.c Player.h Screen.h Screen.c Character.c Bitmaps.c AI.c HotPotato.c Tag.c Timer2.c MusicLibrary.c MusicLibrary.h Menu.c Button0.c SysTick.c SysTick.h Powerup.c UART1.c FIFO.c FIFO.h TwoPlayer.c
